Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowTerminal: DB3073:Family1, DB3073:Family1:899288
Type - Pset_SanitaryTerminalTypeShower - Color: Various
Pset_DistributionFlowElementCommon - Reference: DB3073:Family1; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 920 mm; Host: Level : Level 0; Offset from Host: 920 mm
Dimensions - Area: 0.00716927 m2; Volume: 0.0000498867 m3
Identity Data - Mark: 545
Other - Family: DB3073: Family1; Family and Type: DB3073: Family1; Type: DB3073: Family1; Type Id: DB3073: Family1
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB3090.450:DB3090.450, DB3090.450:DB3090.450:899291
In: Level 0
Type - PredefinedType: SHOWER; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_87_75:Shower fittings package; CodePerformance: WRAS; Color: Brushed Satin; Constituents: n/a; Description: Shower slider rail and holder; DurationUnit: year; ExpectedLife: n/a; Finish: Brushed Satin; Grade: CZ121; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass; ModelNumber: DB3090.450; ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3090.450_ShowerSliderRailAndHolder; Name: ShowerFittingsPackage_WRAS_DB3090.450_ShowerSliderRailAndHolder_DolphinSolutionsLimited; NBSDescription: Showers; NBSReference: 45-35-70/333; NominalHeight: 79 mm; NominalLength: 450mm; NominalWidth: 18 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-blue-450mm-shower-slider-rail-and-holder/; ReplacementCost: n/a; Size: 18x450x79 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB3090.450; Uniclass2015Code: Pr_40_20_87_75; Uniclass2015Title: Shower fittings package; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 2; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB3090.450
Type - Pset_ElementShading - Color: Brushed Satin
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerFittingsPackage_DolphinSolutionsLimited_WRAS_DB3090.450_ShowerSliderRailAndHolder; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerFittingsPackage_WRAS_DB3090.450_ShowerSliderRailAndHolder_DolphinSolutionsLimited; Category: Pr_40_20_87_75:Shower fittings package
Type - Pset_SanitaryTerminalTypeShower - Color: Brushed Satin
Pset_DistributionFlowElementCommon - Reference: DB3090.450:DB3090.450; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 1025 mm; Host: Level : Level 0; Offset from Host: 1025 mm
Dimensions - Area: 0.0274225 m2; Volume: 0.000227501 m3
Identity Data - Mark: 548
Other - Family: DB3090.450: DB3090.450; Family and Type: DB3090.450: DB3090.450; Type: DB3090.450: DB3090.450; Type Id: DB3090.450: DB3090.450
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB5510.M:DB5510.M, DB5510.M:DB5510.M:899330
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 126 mm; Height: 825.128 mm; Width: 416.636 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_89:WCCisterns; CodePerformance: EN14055ClassTwoCompliant_WRAS_ApprovedInletValve; Color: White; Constituents: n/a; Description: 126mm Pneumatic WC Cistern no frame; DurationUnit: year; ExpectedLife: n/a; Features: AUK_BackflowArrangement_Dual flush in-wall cistern compatible with dual flush actuators 6/3 litres (adjustable to 4.5/3)_Delayed refilling (saves up to 9 litres of water per day) BS1212- 4:2016_Working pressure from 0.1 to 16 bar Resistance to atmospheric humidity (Hr <90%); Finish: n/a; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Polypropylene; ModelNumber: DB5510.M; ModelReference: DolphinSolutionsLimited_PneumaticCiesternNoFrame; Name: WCCisterns_PneumaticCisternNoFrame_DB5510.M_DolphinSolutionsLimited; NBSDescription: WC Cisterns; NBSReference: 45-35-70/383; NBSTypeID: n/a; NominalHeight: 425 mm; NominalLength: 126 mm; NominalWidth: 488 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.05.21.14.14; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-blue-126mm-pneumatic-cistern-no-frame/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 488 x 425 x 126 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB5510.M; Uniclass2015Code: Pr_40_20_93_89; Uniclass2015Title: WC Cisterns; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB5510.M
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_PneumaticCiesternNoFrame; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WCCisterns_PneumaticCisternNoFrame_DB5510.M_DolphinSolutionsLimited; Category: Pr_40_20_93_89:WCCisterns
Pset_DistributionFlowElementCommon - Reference: DB5510.M:DB5510.M; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 306.972 mm; Host: Level : Level 0; Offset from Host: 306.972 mm
Dimensions - Area: 0.509606 m2; Volume: 0.0223928 m3; Wall Thickness: 90 mm
Identity Data - Mark: 587
Other - Family: DB5510.M: DB5510.M; Family and Type: DB5510.M: DB5510.M; Type: DB5510.M: DB5510.M; Type Id: DB5510.M: DB5510.M
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB5560.M:DB5560.M, DB5560.M:DB5560.M:899332
In: Level 0
Type - PredefinedType: USERDEFINED; Material: <Unnamed> (8)
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 160 mm; Length: 48 mm; Width: 265 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_75_50_46_31:Flush control devices; CAWS: N13/300 WCs and cisterns_S90/690 Flush control devices_S90/690 Flush control devices; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: DocM Flush Plate; DurationUnit: year; ExpectedLife: n/a; Features: DocM Large Push Panels; Finish: DB5560.M.1_BrushedSatin_DB5560.M.2_Polished_DB5560.M.3_PVD_DB5560.M.5_PowderCoated_DB5560.M.6_CeramicCoated; Grade: 316; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; Material: StainlessSteel; ModelNumber: DB5560.M; ModelReference: DolphinSolutionsLimited_DocMFlushPlate; Name: FlushControlDevices_DocMFlushPlate_DB5560.M_DolphinSolutionsLimited; NBSCode: 90-15-35/470 Flush control devices; NBSDescription: Flush control devices; NBSReference: n/a; NBSTypeID: n/a; NominalHeight: 160 mm; NominalLength: 48 mm; NominalWidth: 265 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.60.50.24; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 160 x 265 x 48 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB5560.M; Uniclass2015Code: Pr_75_50_46_31; Uniclass2015Title: Flush control devices; Uniclass2015Version: Products v1.22; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB5560.M
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_DocMFlushPlate; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: FlushControlDevices_DocMFlushPlate_DB5560.M_DolphinSolutionsLimited; Category: Pr_75_50_46_31:Flush control devices
Pset_DistributionFlowElementCommon - Reference: DB5560.M:DB5560.M; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 973.6 mm; Host: Level : Level 0; Offset from Host: 973.6 mm
Dimensions - Area: 0.0880911 m2; Volume: 0.000768347 m3
Identity Data - Mark: 589
Other - Family: DB5560.M: DB5560.M; Family and Type: DB5560.M: DB5560.M; Type: DB5560.M: DB5560.M; Type Id: DB5560.M: DB5560.M
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB590:Standard, DB590:Standard:899265
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 750 mm; Height: 460 mm; Width: 355 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_94:WC Pans; CodePerformance: EN997�CL2_DocM; Color: White; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Features: Flush volume 6/3 litres; Finish: Gloss; Form: BaskToWallFloorMounted; Grade: n/a; InstallationDate: 31-12-1900 23:59; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Ceramic; ModelNumber: DB590; ModelReference: DolphinSolutionsLimited_WCPan; Name: WCPans_DocM_WCPanFloorMounted_DB590_DolphinSolutionsLimited; NBSDescription: WC Pans; NBSReference: 35-70-70/134; NBSTypeID: n/a; NominalHeight: 460 mm; NominalLength: 750 mm; NominalWidth: 355 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.05.21.11.11; OmniClass Number: 23.45.05.21.11; OmniClass Title: Water Closets; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-doc-m-floor-mounted-toilet-pan/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 355 x 460 x 750 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: Standard; Uniclass2015Code: Pr_40_20_93_94; Uniclass2015Title: WC Pans; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB590
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WCPan
Type - Pset_ProductRequirements - Name: WCPans_DocM_WCPanFloorMounted_DB590_DolphinSolutionsLimited; Category: Pr_40_20_93_94:WC Pans
Pset_DistributionFlowElementCommon - Reference: DB590:Standard; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Elevation from Level: 0 mm; Host: Level : Level 0; Level: Level: Level 0; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.868335 m2; Volume: 0.0770681 m3
Identity Data - Mark: 519
Other - Family: DB590: Standard; Family and Type: DB590: Standard; Type: DB590: Standard; Type Id: DB590: Standard
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB591-GRY:DB591-GRY, DB591-GRY:DB591-GRY:899329
In: Level 0
Type - PredefinedType: WCSEAT; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 20 mm; Length: 440 mm; Width: 353 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_93_95:WC seats and covers; CAWS: N13/300 WCs and cisterns; CodePerformance: DocM; Color: Grey; Constituents: n/a; Description: Grey Toilet seat; DurationUnit: year; ExpectedLife: n/a; Features: antibacterial_seat-only; Finish: n/a; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: WCSEAT; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: DB591-GRY; Material: ThermosetPlastic; ModelNumber: DB591-GRY; ModelReference: DolphinSolutionsLimited_ToiletSeat; Name: WCSeatsAndCovers_ToiletSeat_DB591-GRY_DolphinSolutionsLimited; NBSDescription: WC seats and covers; NBSReference: 45-35-70/391; NBSTypeID: n/a; NominalHeight: 20 mm; NominalLength: 440 mm; NominalWidth: 353 mm; ObjectClassification: 23.45.05.21.14.11; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 353 x 20 x 440 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB591-GRY; Uniclass2015Code: Pr_40_20_93_95; Uniclass2015Title: WC seats and covers; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB591-GRY
Type - Pset_ElementShading - Color: Grey
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_ToiletSeat; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WCSeatsAndCovers_ToiletSeat_DB591-GRY_DolphinSolutionsLimited; Category: Pr_40_20_93_95:WC seats and covers
Pset_DistributionFlowElementCommon - Reference: DB591-GRY:DB591-GRY; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 460 mm; Host: Level : Level 0; Offset from Host: 460 mm
Dimensions - Area: 0.111893 m2; Volume: 0.0017476 m3
Identity Data - Mark: 586
Other - Family: DB591-GRY: DB591-GRY; Family and Type: DB591-GRY: DB591-GRY; Type: DB591-GRY: DB591-GRY; Type Id: DB591-GRY: DB591-GRY
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB785SS:DB785SS, DB785SS:DB785SS:899328
In: Level 0
Type - PredefinedType: WASTETRAP; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Height: 160 mm; Length: 320.25 mm; Width: 32 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_70_55_96_97:Wash basins wastes; CodePerformance: BS EN 274-1:2002 and Approved Document H; Color: BrushedSatin_Polished_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Waste Trap; DurationUnit: year; ExpectedLife: n/a; Features: 1 1/4" Waste_75mmWaterSeal; Finish: Suffix_SS-316BrushedSatin; Grade: 316; IfcExportAs: IfcWasteTerminalType; IfcExportType: WASTETRAP; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: DB785SS; ModelReference: DolphinSolutionsLimited_Dolphin_Blue_WasteTrap; Name: WasteTrap_Blue_SatinSS316_DB785SS_DolphinSolutionsLimited; NBSDescription: Wash basins wastes; NBSReference: 45-35-70/372; NBSTypeID: n/a; NominalHeight: 160; NominalLength: 320; NominalWidth: 32; ObjectClassification: 23.45.55.00; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: DB785SS; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Size: 160x320x32; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB785SS; Uniclass2015Code: Pr_70_55_96_97; Uniclass2015Title: Wash basins wastes; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB785SS
Type - Pset_ElementShading - Color: BrushedSatin_Polished_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Dolphin_Blue_WasteTrap; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WasteTrap_Blue_SatinSS316_DB785SS_DolphinSolutionsLimited; Category: Pr_70_55_96_97:Wash basins wastes
Pset_DistributionFlowElementCommon - Reference: DB785SS:DB785SS; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 379.978 mm; Host: Level : Level 0; Offset from Host: 379.978 mm
Dimensions - Area: 0.0645665 m2; Volume: 0.000375945 m3
Identity Data - Mark: 585
Other - Family: DB785SS: DB785SS; Family and Type: DB785SS: DB785SS; Type: DB785SS: DB785SS; Type Id: DB785SS: DB785SS
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DB793S:DB794S, DB793S:DB794S:899281
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_70_55_96_97:Wash basins wastes; CodePerformance: n/a; Color: BrushedSatin or PowderCoatedRAL; Constituents: n/a; Description: Waste Drain; DurationUnit: year; ExpectedLife: n/a; Features: 1 1/4 waste_Slotted; Finish: BrushedChrome or PowderCoatedRAL; Grade: n/a; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass; ModelNumber: DB793S/DB793-PC; ModelReference: DolphinSolutionsLimited_WasteDrain; Name: WasteDrain_Blue_DB793S_DolphinSolutionsLimited; NBSDescription: Wash basins wastes; NBSReference: 45-35-70/372; NominalHeight: 48mm; NominalLength: 0; NominalWidth: 63mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.55.00; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-blue-waste-drain/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 48 x 63 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DB794S; Uniclass2015Code: Pr_70_55_96_97; Uniclass2015Title: Wash basins wastes; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DB793S
Type - Pset_ElementShading - Color: BrushedSatin or PowderCoatedRAL
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_WasteDrain; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WasteDrain_Blue_DB793S_DolphinSolutionsLimited; Category: Pr_70_55_96_97:Wash basins wastes
Pset_DistributionFlowElementCommon - Reference: DB793S:DB794S; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 570.103 mm; Host: Level : Level 0; Offset from Host: 570.103 mm
Dimensions - Area: 0.0175881 m2; Volume: 0.0000437176 m3
Identity Data - Mark: 537
Other - Family: DB793S: DB794S; Family and Type: DB793S: DB794S; Type: DB793S: DB794S; Type Id: DB793S: DB794S
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DC1155:DC1155, DC1155:DC1155:899334
In: Level 0
Type - PredefinedType: WASHHANDBASIN; Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 348 mm; Width: 451 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_96_96:Wall-hung wash basins; CAWS: N13/30 Washbasins_N13/335 Washbasins; CodePerformance: n/a; Color: White; Constituents: n/a; Description: Wall-hung wash basin for right/left hand transfer; DurationUnit: year; ExpectedLife: n/a; Features: central tap hole; Finish: Glossy; Form: Wall-mounted; Grade: n/a; IfcExportAs: IfcSanitaryTerminalType; IfcExportType: WASHHANDBASIN; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: www.dolphinsolutions.co.uk; Material: Ceramic; ModelNumber: DC1155; ModelReference: DolphinSolutionsLimited_Washbasin; Name: Washbasin_DocM_Wallhungwashbasin_DC1155_DolphinSolutionsLimited; NBSDescription: Wall-hung wash basins; NBSReference: 35-70-70/124; ObjectClassification: Omniclass; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ReplacementCost: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 451w x 348d 145h mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DC1155; Uniclass2015Code: Pr_40_20_96_96; Uniclass2015Title: Washbasins, sinks and troughs; Uniclass2015Version: Products v1.22; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Other - Category: Plumbing Fixtures; Family Name: DC1155
Type - Pset_ElementShading - Color: White
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Washbasin; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Washbasin_DocM_Wallhungwashbasin_DC1155_DolphinSolutionsLimited; Category: Pr_40_20_96_96:Wall-hung wash basins
Type - Pset_SanitaryTerminalTypeWashHandBasin - Color: White
Pset_DistributionFlowElementCommon - Reference: DC1155:DC1155; sets with these values: 2
Pset_ElementShading - sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 719.978 mm; Host: Level : Level 0; Offset from Host: 719.978 mm
Dimensions - Area: 0.325435 m2; Volume: 0.0101615 m3
Identity Data - Mark: 591
Other - Family: DC1155: DC1155; Family and Type: DC1155: DC1155; Type: DC1155: DC1155; Type Id: DC1155: DC1155
Phasing - Phase Created: New Construction

# IfcFlowTerminal: DS213.150.150:DS213.150.150, DS213.150.150:DS213.150.150:899282
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 125 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; BodyIngressProtectionMinimum: IP68 connector; Category: Pr_40_20_87_98:Washbasin Taps; CodePerformance: WRAS; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: InformBasinTap; DurationUnit: year; ElectricalSupplyFrequency: 50/ 60 Hz; ElectricalSupplyRatedOperationalVoltage: Plug in 9v Transformers 100-240V; ExpectedLife: n/a; Features: Up to 70% water savings_BREEAM/ SKA/ LEED/ WELL/ WRAS/ compliant_Flow rate: Max. 3.0 litres/minute between 0.5 and 6.0 bar_Water supply: single inlet cold or pre-mixed � a TMV2 or TMV3 thermostatic mixing valve is recommended for premixed application; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Form: CounterMounted; Grade: 316; InstallationDate: 31-12-1900 23:59; Manufacturer: mailto:info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DS213.150.150; ModelReference: DolphinSolutionsLimited_InformBsainTap; Name: WashBasinTaps_Inform_BasinTap_DS213.150.150_DolphinSolutionsLimited; NBSDescription: WashbasinTaps; NBSReference: 45-35-70/371; NBSTypeID: n/a; NominalHeight: 150 mm; NominalLength: 150 mm; NominalWidth: 22 mm; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.45.55.17; Operation: Automatic; ProductInformation: https://www.dolphinsolutions.co.uk/product/dolphin-inform-basin-tap-2/; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 150 x 150 x 22 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: DS213.150.150; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin Taps; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: DS213.150.150
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_InformBsainTap; Manufacturer: mailto:info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: WashBasinTaps_Inform_BasinTap_DS213.150.150_DolphinSolutionsLimited; Category: Pr_40_20_87_98:Washbasin Taps
Pset_DistributionFlowElementCommon - Reference: DS213.150.150:DS213.150.150; sets with these values: 2
Pset_ProductRequirements - Category: Plumbing Fixtures
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 719.978 mm; Host: Level : Level 0; Offset from Host: 719.978 mm
Dimensions - Area: 0.0207593 m2; Volume: 0.0000445686 m3
Identity Data - Mark: 538
Other - AL0220: yes; Family: DS213.150.150: DS213.150.150; Family and Type: DS213.150.150: DS213.150.150; Type: DS213.150.150: DS213.150.150; Type Id: DS213.150.150: DS213.150.150
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-11:BC5083-11, BC5083-11:BC5083-11:899292
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 1200 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_20_77:Shower curtain rails; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Shower curtain rails; DurationUnit: year; ExpectedLife: n/a; Features: Concealed fixings; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-11; ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_BC5083-11; Name: ShowerCurtainRails_BC5083-11_ShowerCurtainRail_DolphinSolutionsLimited; NBSDescription: Shower curtain rails; NBSReference: 45-35-70/334; NominalLength: 1200 mm; NominalWidth: 1200 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-corner-shower-rail/; ReplacementCost: n/a; Size: 1200x1200; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-11; Uniclass2015Code: Pr_40_30_20_77; Uniclass2015Title: Shower curtain rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-11
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_FurnitureTypeCommon - Description: Shower curtain rails
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainRails_DolphinSolutionsLimited_BC5083-11; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtainRails_BC5083-11_ShowerCurtainRail_DolphinSolutionsLimited; Category: Pr_40_30_20_77:Shower curtain rails
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-11:BC5083-11
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2025 mm; Host: Level : Level 0; Offset from Host: 2025 mm
Dimensions - Area: 0.10303 m2; Volume: 0.00124196 m3
Identity Data - Mark: 549
Other - Family: BC5083-11: BC5083-11; Family and Type: BC5083-11: BC5083-11; Type: BC5083-11: BC5083-11; Type Id: BC5083-11: BC5083-11
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-12:BC5083-12, BC5083-12:BC5083-12:899295
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_20_77:Shower curtain rails; CodePerformance: n/a; Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated; Constituents: n/a; Description: Shower curtain rail ceiling stay; DurationUnit: year; ExpectedLife: n/a; Features: Concealed fixings; Finish: Suffix_.1BrushedSatin_.2Polished_.3PVD_.5PowderCoated_.6CeramicCoated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: BC5083-12; ModelReference: ShowerCurtainRails_CeilingStay_DolphinSolutionsLimited_BC5083-12; Name: ShowerCurtainRails_BC5083-12_ShowerCurtainRailCeilingStay_DolphinSolutionsLimited; NBSDescription: Shower curtain rails; NBSReference: 45-35-70/334; NominalHeight: 500 mm; NominalWidth: 75 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-ceiling-stay/; ReplacementCost: n/a; Size: 75x500; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-12; Uniclass2015Code: Pr_40_30_20_77; Uniclass2015Title: Shower curtain rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-12
Type - Pset_ElementShading - Color: BrushedSatin_Polished_PVD_RAL_PowderCoated_CeramicCoated
Type - Pset_FurnitureTypeCommon - Description: Shower curtain rail ceiling stay
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainRails_CeilingStay_DolphinSolutionsLimited_BC5083-12; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtainRails_BC5083-12_ShowerCurtainRailCeilingStay_DolphinSolutionsLimited; Category: Pr_40_30_20_77:Shower curtain rails
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-12:BC5083-12
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2500 mm; Host: Level : Level 0; Offset from Host: 2500 mm
Dimensions - Area: 0.00895278 m2; Volume: 0.0000298871 m3
Identity Data - Mark: 552
Other - Family: BC5083-12: BC5083-12; Family and Type: BC5083-12: BC5083-12; Type: BC5083-12: BC5083-12; Type Id: BC5083-12: BC5083-12
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-13:BC5083-13 (24)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; CodePerformance: n/a; Color: Chrome; Constituents: n/a; Description: Shower curtain hooks; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Chrome Plated; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: Brass Chrome Plated; ModelNumber: BC5083-13; ModelReference: ShowerCurtainHooks_DolphinSolutionsLimited_BC5083-13; Name: ShowerCurtainHooks_BC5083-13_DolphinSolutionsLimited; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-curtain-hooks-brass-chrome-plated/; ReplacementCost: n/a; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-13; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-13
Type - Pset_ElementShading - Color: Chrome
Type - Pset_FurnitureTypeCommon - Description: Shower curtain hooks
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtainHooks_DolphinSolutionsLimited_BC5083-13; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtainHooks_BC5083-13_DolphinSolutionsLimited
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-13:BC5083-13
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 2025 mm; Host: Level : Level 0; Offset from Host: 2025 mm
Dimensions - Area: 0.0013773 m2; Volume: 0.00000205534 m3
Other - Family: BC5083-13: BC5083-13; Family and Type: BC5083-13: BC5083-13; Type: BC5083-13: BC5083-13; Type Id: BC5083-13: BC5083-13
Phasing - Phase Created: New Construction
Name (BC5083-13:BC5083-13:...) | Mark
899297 | 554
899298 | 555
899299 | 556
899300 | 557
899301 | 558
899302 | 559
899303 | 560
899304 | 561
899305 | 562
899306 | 563
899307 | 564
899308 | 565
899310 | 567
899311 | 568
899312 | 569
899313 | 570
899314 | 571
899315 | 572
899316 | 573
899317 | 574
899318 | 575
899319 | 576
899320 | 577
899321 | 578

# IfcFurnishingElement: BC5083-14:BC5083-14 (2)
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; CodePerformance: n/a; Color: White; Constituents: n/a; Description: Shower curtain; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: 4oz Weighted White Polyester; ModelNumber: BC5083-14; ModelReference: ShowerCurtain_DolphinSolutionsLimited_BC5083-14; Name: ShowerCurtain_BC5083-14_DolphinSolutionsLimited; NominalHeight: 1830 mm; NominalLength: 1830 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.17; OmniClass Number: 23.40.20.21.44; OmniClass Title: Shower Rods, Curtains; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-curtain/; ReplacementCost: n/a; Size: 1830x1830; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-14; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-14
Type - Pset_ElementShading - Color: White
Type - Pset_FurnitureTypeCommon - Description: Shower curtain
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerCurtain_DolphinSolutionsLimited_BC5083-14; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerCurtain_BC5083-14_DolphinSolutionsLimited
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-14:BC5083-14
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 125 mm; Host: Level : Level 0; Offset from Host: 125 mm
Dimensions - Area: 1.91829 m2; Volume: 0.00191533 m3
Other - Family: BC5083-14: BC5083-14; Family and Type: BC5083-14: BC5083-14; Type: BC5083-14: BC5083-14; Type Id: BC5083-14: BC5083-14
Phasing - Phase Created: New Construction
Name (BC5083-14:BC5083-14:...) | Mark
899296 | 553
899309 | 566

# IfcFurnishingElement: BC5083-33:BC5083-33, BC5083-33:BC5083-33:899294
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_06_83:Shower seats; CodePerformance: BSEN12182; Color: Pale grey_white metal; Constituents: n/a; Description: Shower seat; DurationUnit: year; ExpectedLife: n/a; Finish: n/a; IfcExportAs: IfcFurnitureType; IfcExportType: CHAIR; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: DiecastAluminium_VacuumMouldedPolyethylene; ModelNumber: BC5083-33; ModelReference: ShowerSeats_DolphinSolutionsLimited_BC5083-33_ShowerSeat; Name: ShowerSeats_BC5083-33_ShowerSeat_DolphinSolutionsLimited; NBSDescription: Shower seats; NBSReference: 45-35-72/352; NominalHeight: 220 mm; NominalLength: 650 mm; NominalWidth: 450 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.11.17; OmniClass Number: 23.45.05.14.11.17; OmniClass Title: Shower/Bath Seats; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-seat/; ReplacementCost: n/a; Shape: Rectangular; Size: 450x650x220; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-33; Uniclass2015Code: Pr_40_20_06_83; Uniclass2015Title: Shower seats; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-33
Type - Pset_ElementShading - Color: Pale grey_white metal
Type - Pset_FurnitureTypeCommon - Description: Shower seat
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerSeats_DolphinSolutionsLimited_BC5083-33_ShowerSeat; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerSeats_BC5083-33_ShowerSeat_DolphinSolutionsLimited; Category: Pr_40_20_06_83:Shower seats
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-33:BC5083-33
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 485 mm; Host: Level : Level 0; Offset from Host: 485 mm
Dimensions - Area: 0.372725 m2; Volume: 0.0101955 m3
Identity Data - Mark: 551
Other - Family: BC5083-33: BC5083-33; Family and Type: BC5083-33: BC5083-33; Type: BC5083-33: BC5083-33; Type Id: BC5083-33: BC5083-33
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC5083-34:BC5083-34, BC5083-34:BC5083-34:899293
In: Level 0
Type - Material: <Unnamed>
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_06_83:Shower seats; Color: Pale grey_white metal; Constituents: n/a; Description: Shower seat back rest; DurationUnit: year; ExpectedLife: n/a; Finish: n/a; IfcExportAs: IfcFurnitureType; IfcExportType: USERDEFINED; InstallationDate: 31-12-1900 23:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: DiecastAluminium_VacuumMouldedPolyethylene; ModelNumber: BC5083-34; ModelReference: ShowerSeat_DolphinSolutionsLimited_BC5083-34_ShowerSeatBackRest; Name: ShowerSeat_BC5083-34_ShowerSeatBackRest_DolphinSolutionsLimited; NBSDescription: Shower seats; NBSReference: 45-35-72/352; NominalHeight: 189 mm; NominalLength: 160 mm; NominalWidth: 450 mm; ObjectClassification1: OmniClass; ObjectClassification2: 23.45.05.14.11.17; OmniClass Number: 23.45.05.14.11.17; OmniClass Title: Shower/Bath Seats; Product Information: https://www.dolphinsolutions.co.uk/product/dolphin-shower-back-rest/; ReplacementCost: n/a; Shape: Rectangular; Size: 450x160x189; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5083-34; Uniclass2015Code: Pr_40_20_06_83; Uniclass2015Title: Shower seats; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: DolphinSolutionsLimited; WarrantyGuarantorParts: DolphinSolutionsLimited; WarrantyStartDate: 31-12-1900 23:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5083-34
Type - Pset_ElementShading - Color: Pale grey_white metal
Type - Pset_FurnitureTypeCommon - Description: Shower seat back rest
Type - Pset_ManufacturerOccurrence - BarCode: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: ShowerSeat_DolphinSolutionsLimited_BC5083-34_ShowerSeatBackRest; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: ShowerSeat_BC5083-34_ShowerSeatBackRest_DolphinSolutionsLimited; Category: Pr_40_20_06_83:Shower seats
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5083-34:BC5083-34
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 820 mm; Host: Level : Level 0; Offset from Host: 820 mm
Dimensions - Area: 0.152202 m2; Volume: 0.00723579 m3
Identity Data - Mark: 550
Other - Family: BC5083-34: BC5083-34; Family and Type: BC5083-34: BC5083-34; Type: BC5083-34: BC5083-34; Type Id: BC5083-34: BC5083-34
Phasing - Phase Created: New Construction

# IfcFurnishingElement: BC754:BC754, BC754:BC754:899331
In: Level 0
Type - Material: Default
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 200 mm; Height: 50 mm; Width: 400 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_30_78_78:Shelves; CAWS: N13/449 Shelves; CodePerformance: n/a; Color: Brushed Satin_RAL Colours; Constituents: n/a; Description: Shelf; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Brushed Satin_PowderCoated; Form: Wall-mounted; Grade: 304; IfcExportAs: IfcFurnitureType; IfcExportType: Shelf; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: BC754; ModelReference: DolphinSolutionsLimited_Shelf; Name: Shelves_Shelf_BC754_DolphinSolutionsLimited; NBSDescription: Shelves; NBSReference: 45-35-80/320; NBSTypeID: n/a; NominalHeight: 50; NominalLength: 400; NominalWidth: 200; ObjectClassification: 23.40.20.27.11; ObjectClassification_1: OmniClass; ObjectClassification_2: 23.40.20.27.11; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: Rectangular; Size: 200 x 400 x 50 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC754; Uniclass2015Code: Pr_40_30_78_78; Uniclass2015Title: Shelves; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Materials and Finishes - Primary Material: Default
Type - Other - Category: Plumbing Fixtures; Family Name: BC754
Type - Pset_ElementShading - Color: Brushed Satin_RAL Colours
Type - Pset_FurnitureTypeCommon - Description: Shelf; NominalHeight: 15240 mm; NominalLength: 121920 mm
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Shelf; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_ProductRequirements - Name: Shelves_Shelf_BC754_DolphinSolutionsLimited; Category: Pr_40_30_78_78:Shelves
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC754:BC754
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 710 mm; Host: Level : Level 0; Offset from Host: 710 mm
Dimensions - Area: 0.126358 m2; Volume: 0.000250292 m3
Identity Data - Mark: 588
Other - Family: BC754: BC754; Family and Type: BC754: BC754; Type: BC754: BC754; Type Id: BC754: BC754
Phasing - Phase Created: New Construction

# IfcRailing: BC5063-05:BC5063-05, BC5063-05:BC5063-05:899333
In: Level 0
Type - PredefinedType: HANDRAIL; Material: <Unnamed>
Type - Constraints - Default Elevation: 1219.2 mm
Type - Dimensions - Heigth: 92 mm; Length: 500 mm; Width: 32 mm
Type - Identity Data - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_84:SupportRails; CAWS: N13/69 Support rails and grab bars_N13/436 Handrails and grab bars; CodePerformance: BSEN12182; Color: Brushed Satin_Various; Constituents: n/a; Description: 500mm long roseless 32mm grab rail; DurationUnit: year; ExpectedLife: n/a; Features: Roseless 60mm wall clearance; Finish: Brushed Satin_Suffix.5-PowderCoated_.6-CeramicCoated; Form: Wall-mounted; Grade: 304; IfcExportAs: IfcRailingType; IfcExportType: HANDRAIL; InstallationDate: 31-12-1900 23:59:59; Manufacturer: info@dolphinsolutions.co.uk; ManufacturerName: DolphinsolutionsLimited; ManufacturerURL: Dolphin Solutions Limited; Material: StainlessSteel; ModelNumber: BC5063-05; ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Name: SupportRails_Roseless32mmGrabRail_BC5063-05_DolphinSolutionsLimited; NBSDescription: Support rails; NBSReference: 45-35-72/360; NBSTypeID: n/a; NominalHeight: 92 mm; NominalLength: 500 mm; NominalWidth: 32 mm; ObjectClassification: 23.40.20.27.14; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; ProductInformation: BC5063-05; ReplacementCost: n/a; Revision: n/a; SerialNumber: n/a; Shape: n/a; Size: 500 x 32 x 92 mm; SustainabilityPerformance: n/a; TagNumber: n/a; Type Name: BC5063-05; Uniclass2015Code: Pr_40_20_76_84; Uniclass2015Title: Support rails; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a; WarrantyStartDate: 31-12-1900 23:59:59
Type - Other - Category: Plumbing Fixtures; Family Name: BC5063-05
Type - Pset_ElementShading - Color: Brushed Satin_Various
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - ModelReference: DolphinSolutionsLimited_Roseless32mmGrabRail; Manufacturer: info@dolphinsolutions.co.uk
Type - Pset_PrecastConcreteElementGeneral - SerialNumber: n/a
Type - Pset_ProductRequirements - Name: SupportRails_Roseless32mmGrabRail_BC5063-05_DolphinSolutionsLimited; Category: Pr_40_20_76_84:SupportRails
Type - Pset_RailingCommon - IsExternal: no
Pset_ProductRequirements - Category: Plumbing Fixtures
Pset_QuantityTakeOff - Reference: BC5063-05:BC5063-05
Pset_RailingCommon - Reference: BC5063-05:BC5063-05
Constraints - Level: Level: Level 0; Moves With Nearby Elements: no; Elevation from Level: 664 mm; Host: Level : Level 0; Offset from Host: 664 mm
Dimensions - Area: 0.0310315 m2; Volume: 0.000483638 m3
Identity Data - Mark: 590
Other - Family: BC5063-05: BC5063-05; Family and Type: BC5063-05: BC5063-05; Type: BC5063-05: BC5063-05; Type Id: BC5063-05: BC5063-05
Phasing - Phase Created: New Construction
